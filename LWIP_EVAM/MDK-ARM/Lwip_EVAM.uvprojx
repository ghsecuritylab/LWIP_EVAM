# Keil uVision project Lwip_EVAM.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lwip_EVAM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ..\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\BSP\STM324x9I_EVAL;..\Drivers\BSP\Components;..\Third_Party\LwIP\src\include;..\Third_Party\LwIP\system;..\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Third_Party\FreeRTOS\Source\include;..\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Utilities;..\Utilities\Log;..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/Utilities
    ../Utilities/Log/: lcd_log.c
  group Application/User
    ../Src/: app_ethernet.c main.c ethernetif.c stm32f4xx_it.c udpecho.c tcpecho.c stm32f4xx_hal_timebase_tim.c
  group Drivers/BSP/STM324x9I_EVAL
    ../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c stm324x9i_eval_lcd.c stm324x9i_eval_sdram.c stm324x9i_eval_debug.c
  group Middlewares/LwIP/Core/IPv4
    ../Third_Party/LwIP/src/core/ipv4/: ip4_addr.c autoip.c ip4.c dhcp.c igmp.c icmp.c etharp.c ip4_frag.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Third_Party/FreeRTOS/Source/: timers.c croutine.c list.c tasks.c queue.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr_ex.c
  group Middlewares/FreeRTOS/portable
    ../Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP/Api
    ../Third_Party/LwIP/src/api/: api_msg.c netifapi.c netbuf.c tcpip.c err.c netdb.c api_lib.c sockets.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Middlewares/LwIP/Core
    ../Third_Party/LwIP/src/core/: raw.c inet_chksum.c ip.c def.c init.c timeouts.c netif.c udp.c tcp_out.c pbuf.c tcp.c sys.c mem.c memp.c dns.c stats.c tcp_in.c
  group Middlewares/LwIP/Netif
    ../Third_Party/LwIP/src/netif/: ethernet.c
    ../Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
