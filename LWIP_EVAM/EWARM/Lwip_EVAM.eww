<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lwip_EVAM.ewp</path>
    </project>
    <batchBuild />
</workspace>
