# IAR project Lwip_EVAM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lwip_EVAM.srec
  ILINK.IlinkOutputFile: Lwip_EVAM.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM324x9I_EVAL; USE_HAL_DRIVER; STM32F429xx; LWIP_DEBUG
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\BSP\STM324x9I_EVAL; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\BSP\STM324x9I_EVAL; ..\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\Third_Party\FreeRTOS\Source\include; ..\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Third_Party\LwIP\system; ..\Third_Party\LwIP\src\include\
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Lwip_EVAM.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: app_ethernet.c ethernetif.c main.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c tcpecho.c udpecho.c
  group Application/Utilities
    ../Utilities/Log/: lcd_log.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM324x9I_EVAL
    ../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_debug.c stm324x9i_eval_io.c stm324x9i_eval_lcd.c stm324x9i_eval_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares/FreeRTOS
    ../Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/portabel
    ../Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Lwip/Api
    ../Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Lwip/Core
    ../Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Lwip/Core/IPv4
    ../Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Lwip/Netif
    ../Third_Party/LwIP/src/netif/: ethernet.c
    ../Third_Party/LwIP/system/OS/: sys_arch.c
